# SPDX-FileCopyrightText: Copyright (c) 2026 Jason Perlow
# SPDX-License-Identifier: Apache-2.0

require cix-multimedia.inc

SUMMARY = "CIX-optimized VA-API runtime library"
DESCRIPTION = "Closed-source CIX Multimedia SDK build of libva 2.22.1 for the CIX Sky1 multimedia stack. Source package: cix-libva2_2.22.1-1_arm64.deb."

CIX_MM_DEB_GLOB = "cix-libva2_2.22.1-1_arm64.deb"
