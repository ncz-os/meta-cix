# SPDX-FileCopyrightText: Copyright (c) 2026 Jason Perlow
# SPDX-License-Identifier: Apache-2.0

require cix-multimedia.inc

SUMMARY = "CIX-optimized FFmpeg libavutil 5.1.7"
DESCRIPTION = "Closed-source CIX Multimedia SDK build of FFmpeg libavutil. Source package: cix-libavutil57_5.1.7-0+deb12u1+b1_arm64.deb."

CIX_MM_DEB_GLOB = "cix-libavutil57_5.1.7-0+deb12u1+b1_arm64.deb"
