# SPDX-FileCopyrightText: Copyright (c) 2026 Jason Perlow
# SPDX-License-Identifier: Apache-2.0

require cix-multimedia.inc

SUMMARY = "CIX NNStreamer package"
DESCRIPTION = "Closed-source CIX Multimedia SDK NNStreamer package for Sky1 multimedia and AI pipelines. Source package: cix-nnstreamer_2.4.2_arm64.deb."

CIX_MM_DEB_GLOB = "cix-nnstreamer_2.4.2_arm64.deb"
